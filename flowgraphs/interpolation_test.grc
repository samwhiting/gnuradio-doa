<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>interpolation_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>94.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>1e5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>down_width</value></param>
<param><key>value</key><value>n_points/downsample</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>downsample</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>drift</value></param>
<param><key>block_id</key><value>probe2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_width</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>lag</value></param>
<param><key>block_id</key><value>probe1</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>lag2</value></param>
<param><key>block_id</key><value>probe3</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>lag_of_signals</value></param>
<param><key>value</key><value>lag</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>Shift from correlation</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>lag_of_signals_2</value></param>
<param><key>value</key><value>lag2</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label</key><value>Shift from correlation</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode_samples</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_points</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.1415926535</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rtl_samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slope_samples</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>speed_of_light</value></param>
<param><key>value</key><value>299792458</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition</value></param>
<param><key>value</key><value>2e5</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>lag</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>lag2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/darsor/matlab/lindelay1.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/darsor/matlab/lindelay2.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>downsample</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>downsample</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0</value></param>
<param><key>n</key><value>downsample</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_1</value></param>
<param><key>n</key><value>downsample</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>10</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/10.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>down_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>down_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>down_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>down_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>slope_samples</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>slope_samples</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_3</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_items</key><value>mode_samples</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>slope_samples</value></param>
</block>
<block>
<key>cross_correlation</key>
<param><key>id</key><value>cross_correlation_0</value></param>
<param><key>xcorr_width</key><value>8192</value></param>
</block>
<block>
<key>cross_correlation</key>
<param><key>id</key><value>cross_correlation_0_0</value></param>
<param><key>xcorr_width</key><value>8192</value></param>
</block>
<block>
<key>doa_capon_ccf</key>
<param><key>id</key><value>doa_capon_ccf_0</value></param>
<param><key>vlen</key><value>down_width</value></param>
</block>
<block>
<key>doa_capon_ccf</key>
<param><key>id</key><value>doa_capon_ccf_0_0</value></param>
<param><key>vlen</key><value>down_width</value></param>
</block>
<block>
<key>doa_cub_delay_cc</key>
<param><key>id</key><value>doa_cub_delay_cc_0</value></param>
<param><key>delay</key><value>-drift</value></param>
<param><key>samp_rate</key><value>rtl_samp_rate</value></param>
</block>
<block>
<key>doa_lin_delay_cc</key>
<param><key>id</key><value>doa_lin_delay_cc_0</value></param>
<param><key>delay</key><value>-drift</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>rtl_samp_rate</value></param>
</block>
<block>
<key>doa_linearslope_ff</key>
<param><key>id</key><value>doa_linearslope_ff_0</value></param>
<param><key>vector_size</key><value>slope_samples</value></param>
</block>
<block>
<key>doa_linearslope_ff</key>
<param><key>id</key><value>doa_linearslope_ff_0_0</value></param>
<param><key>vector_size</key><value>slope_samples</value></param>
</block>
<block>
<key>doa_mode_ii</key>
<param><key>id</key><value>doa_mode_ii_0</value></param>
<param><key>max_value</key><value>fft_width</value></param>
<param><key>vector_size</key><value>mode_samples</value></param>
</block>
<block>
<key>doa_peak_estimator_cff</key>
<param><key>id</key><value>doa_peak_estimator_cff_0</value></param>
<param><key>vector_len</key><value>fft_width</value></param>
</block>
<block>
<key>doa_unwrap_ff</key>
<param><key>id</key><value>doa_unwrap_ff_0</value></param>
<param><key>max</key><value>3.14159265</value></param>
<param><key>min</key><value>-3.14159265</value></param>
<param><key>vector_size</key><value>slope_samples</value></param>
</block>
<block>
<key>doa_unwrap_ff</key>
<param><key>id</key><value>doa_unwrap_ff_0_0</value></param>
<param><key>max</key><value>3.14159265</value></param>
<param><key>min</key><value>-3.14159265</value></param>
<param><key>vector_size</key><value>slope_samples</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>rtl_samp_rate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>rtl_samp_rate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Unwrapped phase vs. Time"</value></param>
<param><key>size</key><value>slope_samples</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>"Unwrapped phase"</value></param>
<param><key>yunit</key><value>"Time"</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Slope of capon angle vs. Time"</value></param>
<param><key>size</key><value>20</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>"Rate of change of capon angle (samples/s)"</value></param>
<param><key>yunit</key><value>"Time"</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Slope of capon angle vs. Time"</value></param>
<param><key>size</key><value>20</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>"Rate of change of capon angle (samples/s)"</value></param>
<param><key>yunit</key><value>"Time"</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_width</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>10000000</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>"rtl=0"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rtl_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>"rtl=1"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rtl_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>label1</key><value>Tab 1</value></param>
<param><key>label2</key><value>Tab 2</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>to_radians_per_second</value></param>
<param><key>const</key><value>rtl_samp_rate/float(n_points)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>to_radians_per_second_0</value></param>
<param><key>const</key><value>rtl_samp_rate/n_points</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>to_samples_per_second</value></param>
<param><key>const</key><value>rtl_samp_rate/(center_freq*2*pi)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>to_samples_per_second_0</value></param>
<param><key>const</key><value>rtl_samp_rate/(center_freq*2*pi)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_argmax_xx_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_argmax_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>blocks_stream_to_vector_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_1</source_block_id><sink_block_id>probe3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>probe2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>doa_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>doa_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>doa_capon_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>doa_capon_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2</source_block_id><sink_block_id>doa_unwrap_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2_0</source_block_id><sink_block_id>doa_unwrap_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_3</source_block_id><sink_block_id>doa_mode_ii_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cross_correlation_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cross_correlation_0_0</source_block_id><sink_block_id>doa_peak_estimator_cff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_capon_ccf_0</source_block_id><sink_block_id>blocks_stream_to_vector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_capon_ccf_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_capon_ccf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_cub_delay_cc_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_cub_delay_cc_0</source_block_id><sink_block_id>cross_correlation_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_cub_delay_cc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_cub_delay_cc_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_cub_delay_cc_0</source_block_id><sink_block_id>cross_correlation_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_lin_delay_cc_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_lin_delay_cc_0</source_block_id><sink_block_id>cross_correlation_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_lin_delay_cc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_lin_delay_cc_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_lin_delay_cc_0</source_block_id><sink_block_id>cross_correlation_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_linearslope_ff_0</source_block_id><sink_block_id>to_radians_per_second</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_linearslope_ff_0_0</source_block_id><sink_block_id>to_radians_per_second_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_mode_ii_0</source_block_id><sink_block_id>probe1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_peak_estimator_cff_0</source_block_id><sink_block_id>blocks_float_to_int_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_peak_estimator_cff_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_unwrap_ff_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_unwrap_ff_0</source_block_id><sink_block_id>doa_linearslope_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_unwrap_ff_0_0</source_block_id><sink_block_id>doa_linearslope_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>cross_correlation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>doa_cub_delay_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>doa_lin_delay_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>cross_correlation_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>doa_cub_delay_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>doa_lin_delay_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>to_radians_per_second</source_block_id><sink_block_id>to_samples_per_second</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>to_radians_per_second_0</source_block_id><sink_block_id>to_samples_per_second_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>to_samples_per_second</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>to_samples_per_second</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>to_samples_per_second_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
