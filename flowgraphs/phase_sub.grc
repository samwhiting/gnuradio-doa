<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>big_fft_width</value></param>
<param><key>value</key><value>2**14</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>broadside_cal</value></param>
<param><key>value</key><value>False</value></param>
<param><key>label</key><value>Calibrate Broadside</value></param>
<param><key>pressed</key><value>False</value></param>
<param><key>released</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>467.5625e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>15e3</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>delay1</value></param>
<param><key>block_id</key><value>probe82</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay2</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay_small</value></param>
<param><key>value</key><value>(delay1&lt;delay2)*delay1 + (delay2&lt;delay1)*delay2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>doa_angle</value></param>
<param><key>block_id</key><value>probe43</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>down_width</value></param>
<param><key>value</key><value>n_points/downsample</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>downsample</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_offset</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_width</value></param>
<param><key>value</key><value>2**11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>25.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lowest</value></param>
<param><key>value</key><value>(delay_small&lt;0)*delay_small</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_points</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>broadside_cal*-doa_angle</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.1415926535</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rtl_samp_rate</value></param>
<param><key>value</key><value>2048000/8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>speed_of_light</value></param>
<param><key>value</key><value>299792458</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition</value></param>
<param><key>value</key><value>20e4</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_2</value></param>
<param><key>value</key><value>delay1</value></param>
<param><key>gui_hint</key><value>tab@0:0,1,1,1</value></param>
<param><key>label</key><value>Big Delay: 1 and 2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>Phase_Diff_cc</key>
<param><key>id</key><value>Phase_Diff_cc_0</value></param>
<param><key>fft_offset</key><value>fft_offset</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
</block>
<block>
<key>Phase_Diff_cc</key>
<param><key>id</key><value>Phase_Diff_cc_0_0</value></param>
<param><key>fft_offset</key><value>fft_offset+1</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
</block>
<block>
<key>Phase_Diff_cc</key>
<param><key>id</key><value>Phase_Diff_cc_0_1</value></param>
<param><key>fft_offset</key><value>fft_offset+2</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_1</value></param>
<param><key>const</key><value>offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_2</value></param>
<param><key>const</key><value>offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay1-lowest</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>-lowest</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>downsample</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>downsample</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>down_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>down_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>big_fft_width</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>big_fft_width</value></param>
</block>
<block>
<key>doa_capon_ccf</key>
<param><key>id</key><value>doa_capon_ccf_0</value></param>
<param><key>vlen</key><value>down_width</value></param>
</block>
<block>
<key>doa_hold_ff</key>
<param><key>id</key><value>doa_hold_ff_0</value></param>
<param><key>hold</key><value>broadside_cal</value></param>
</block>
<block>
<key>doa_pi2pi_ff</key>
<param><key>id</key><value>doa_pi2pi_ff_0</value></param>
</block>
<block>
<key>doa_pi2pi_ff</key>
<param><key>id</key><value>doa_pi2pi_ff_0_0</value></param>
</block>
<block>
<key>doa_pi2pi_ff</key>
<param><key>id</key><value>doa_pi2pi_ff_0_1</value></param>
</block>
<block>
<key>doa_pi2pi_ff</key>
<param><key>id</key><value>doa_pi2pi_ff_0_2</value></param>
</block>
<block>
<key>doa_sample_offset_cci</key>
<param><key>id</key><value>doa_sample_offset_cci_0</value></param>
<param><key>num_xcorr</key><value>10</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>vector_len</key><value>big_fft_width</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_width</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fft_width</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>rtl_samp_rate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>cutoff_freq</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>rtl_samp_rate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Sample alignment</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe43</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe82</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>key</key><value>recalc</value></param>
<param><key>label</key><value>Recalcuate Sample Offset</value></param>
<param><key>is_static</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>rtl_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Capon DOA"</value></param>
<param><key>size</key><value>20</value></param>
<param><key>srate</key><value>rtl_samp_rate/n_points</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Bin 1</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Bin 2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Bin 3</value></param>
<param><key>name</key><value>"Phase Sub"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>100</value></param>
<param><key>srate</key><value>rtl_samp_rate/fft_width</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>"rtl=0"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rtl_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>"rtl=1"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rtl_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>bb_gain1</key><value>20</value></param>
<param><key>dc_offset_mode1</key><value>0</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>center_freq</value></param>
<param><key>gain_mode1</key><value>True</value></param>
<param><key>if_gain1</key><value>20</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>gain1</key><value>10</value></param>
<param><key>args</key><value>"rtl=0, rtl=1"</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rtl_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>label1</key><value>Tab 1</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>Phase_Diff_cc_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Phase_Diff_cc_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Phase_Diff_cc_0_1</source_block_id><sink_block_id>blocks_add_const_vxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>doa_pi2pi_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>doa_pi2pi_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_1</source_block_id><sink_block_id>doa_pi2pi_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_2</source_block_id><sink_block_id>doa_pi2pi_ff_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>doa_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>doa_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>doa_sample_offset_cci_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_0</source_block_id><sink_block_id>doa_sample_offset_cci_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_capon_ccf_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_hold_ff_0</source_block_id><sink_block_id>probe43</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_pi2pi_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_pi2pi_ff_0_0</source_block_id><sink_block_id>doa_hold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_pi2pi_ff_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_pi2pi_ff_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_pi2pi_ff_0_2</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>doa_sample_offset_cci_0</source_block_id><sink_block_id>probe82</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>Phase_Diff_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>Phase_Diff_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>Phase_Diff_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>Phase_Diff_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>Phase_Diff_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>Phase_Diff_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>doa_sample_offset_cci_0</sink_block_id><source_key>msg</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_1</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
